# IAR project AngleMKZ.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: startup\; src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AngleMKZ_Debug.bin
  ILINK.IlinkOutputFile: AngleMKZ.out
  ILINK.IlinkIcfFile: C:\Users\Konstantin\Desktop\Темы\DigitalMoevs\project DigitalMoevs\Angle MK Z\1986VE9xT\linker\MDR32F1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: startup\; src\
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: AngleMKZ_Release.bin
  ILINK.IlinkIcfFile: 1986VE9xT\linker\MDR32F1.icf
  group (top)
    ./: main.c
    src/: SystemInit.c
  group loader
    src/: loaders.c selfLoader.c
  group lowlevel
    src/: can.c dac.c flash1986ve9x.c timers.c
  group src
    src/: adcrt.c angleService.c canmonitor.c canterminal.c dusFilter.c flashUserData.c
  group startup
    startup/: core_cm3.h define_type.h MDR32Fx.h startup_MDR32F9Qx.s
